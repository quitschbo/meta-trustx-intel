inherit trustmex86
